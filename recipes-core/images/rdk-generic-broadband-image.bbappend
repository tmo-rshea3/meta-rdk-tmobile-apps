IMAGE_INSTALL += " \
    gcc-sanitizers \
    usp-pa \
    "
